FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://fdt.cfg"
